<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>polyphonic_synthesizer_testbed</value></param>
<param><key>author</key><value>Scott</value></param>
<param><key>catch_exceptions</key><value>1</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq</key><value>440</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.PMT_NIL, pmt.init_f32vector(256, [0.1 if n in (150, 168, 189) else 0.0 for n in range(256)]))</value></param>
<param><key>period</key><value>400</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.PMT_NIL, pmt.init_f32vector(256, [0.1 if n in (120, 155) else 0.0 for n in range(256)]))</value></param>
<param><key>period</key><value>150</value></param>
</block>
<block>
<key>obrot_polyphonic_synthesizer</key>
<param><key>id</key><value>obrot_polyphonic_synthesizer_0</value></param>
<param><key>end_octave</key><value>8</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>start_octave</key><value>0</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>obrot_polyphonic_synthesizer_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>obrot_polyphonic_synthesizer_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>obrot_polyphonic_synthesizer_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
